# Keil uVision project HZZH.uvprojx, settings and files
target HZZH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: App +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin -o  .\Bin\download.bin .\Objects\App.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,ARM
  c include: ..\APP;..\APP\Tool;..\APP\Config;..\LIB;..\APP\Plate;..\APP\Pack
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: FSM.c MainTask.c Reset.c Teach.c AppInit.c main.c Logic.c iodefine.h Logic.h DataDefine.h
  group App.Plate
    ../APP/Plate/: Plate.c Plate.h Adjust.c Adjust.h Blow.c Blow.h Detect.c Detect.h DownCamera.c DownCamera.h ElecTest.c ElecTest.h ElecTurn.c ElecTurn.h Feed.c Feed.h Clean.c Clean.h
  group App.Pack
    ../APP/Pack/: Pack.c Pack.h Belt.c Belt.h Cut.c Cut.h Film.c Film.h Press.c Press.h Repack.c Repack.h UpCamera.c UpCamera.h
  group Tool
    ../APP/Tool/: AxisMove.c AxisMove.h LockNew.c UserTool.c Uph.c Timer.c Timer.h Trigger.c Trigger.h GpioManager.c GpioManager.h Encipherment.c Encipherment.h
  group Config
    ../APP/Config/: AxisConfig.c bsp_config.c InterLayer.c
    ./: startup_stm32f40_41xxx.s
  group LIB
    ../LIB/: Algorithm_ver_00_01_09.lib can_master.lib INTERLAYER_VER01_10_17.lib can_master.h Interlayer_config.h Axis6_v00_00_03_lib.lib BspLib.h
